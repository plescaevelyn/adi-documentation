options:
  parameters:
    generate_options: qt_gui
    id: console_message_receiver_jupiter
    output_language: python
    title: console_message_receiver_jupiter
  states: {}

blocks:
- name: alpha
  id: variable
  parameters:
    comment: |-
      Can't change alpha in real time
      for Consteallation Modulator
    value: '0.50'
  states: {}
- name: buff_size
  id: variable
  parameters:
    value: int(32768)
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '3200000000'
  states: {}
- name: constellation
  id: variable_constellation
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    type: calcdist
  states: {}
- name: gain_control_mode_rx0
  id: variable
  parameters:
    value: '''automatic'''
  states: {}
- name: interval_update
  id: variable
  parameters:
    value: int(0)
  states: {}
- name: jupiter_ip
  id: variable_config
  parameters:
    config_file: default
    option: key
    section: main
    type: string
    value: ip:jupiter.local
    writeback: None
  states: {}
- name: msg_rx
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0
    type: raw
    value: '0'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: offset_rx
  id: variable
  parameters:
    value: '-150000'
  states: {}
- name: rcc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: alpha
    gain: nfilts
    ntaps: 11*sps*nfilts
    samp_rate: nfilts*samp_rate
    sym_rate: samp_rate/sps
  states: {}
- name: rx_lo_freq
  id: variable
  parameters:
    value: int(center_freq)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1920000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '16'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: offset_rx
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    alias: msg_var
    target: msg_rx
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '32768'
  states: {}
- name: blocks_short_to_float_0_1
  id: blocks_short_to_float
  parameters:
    scale: '32768'
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    comment: |-
      Skip one second of samples
      to allow AGC and FLL to lock
    num_items: int(samp_rate)
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: constellation.bits_per_symbol()
  states: {}
- name: digital_constellation_receiver_cb_0
  id: digital_constellation_receiver_cb
  parameters:
    comment: |-
      Input comes from Symbol Sync
      Includes a Costas Loop to do phase sync
    constellation: constellation
    fmax: math.pi
    fmin: '-math.pi'
    loop_bw: 2*math.pi*0.03
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '"11100001010110101110100010010011"'
    tagname: packet_len
    threshold: '1'
    type: byte
  states: {}
- name: digital_crc_check_0
  id: digital_crc_check
  parameters:
    discard_crc: 'True'
    poly: '0x4C11DB7'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: constellation.arity()
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: sps*2+1
    rolloff: alpha
    samps_per_sym: sps
    type: cc
    w: 2*math.pi/sps/100/sps
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: constellation
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1'
    nfilters: nfilts
    osps: '1'
    pfb_mf_taps: rcc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\n\ndataBuf = []\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    def __init__(self):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='ASCII Conversion Python Block',   # will show up in GRC\n            in_sig=None,\n            out_sig=None\n        )\n        self.message_port_register_in(gr.pmt.intern('msg_in'))\n        self.message_port_register_out(gr.pmt.intern('clear_input'))\n        self.set_msg_handler(gr.pmt.intern('msg_in'), self.handle_msg)\n    \n    def handle_msg(self, msg):\n        global dataBuf\n        dataBuf = gr.pmt.to_python(gr.pmt.cdr(msg)) # this one returns a python list\n        proc=[str(chr(x)) for x in dataBuf]\n        final_msg = \"\".join(proc)\n        self.message_port_pub(gr.pmt.intern('clear_input'), gr.pmt.cons(gr.pmt.PMT_NIL, gr.pmt.to_pmt(final_msg)))\n\n"
  states: {}
- name: iio_attr_sink_0_0
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: voltage1
    device: adrv9002-phy
    output: 'False'
    uri: jupiter_ip
  states: {}
- name: iio_attr_sink_0_0_0
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: voltage1
    device: adrv9002-phy
    output: 'True'
    uri: jupiter_ip
  states: {}
- name: iio_attr_sink_0_1_0
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: altvoltage0
    device: adrv9002-phy
    output: 'True'
    uri: jupiter_ip
  states: {}
- name: iio_attr_sink_0_1_0_1
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: voltage0
    device: adrv9002-phy
    output: 'False'
    uri: jupiter_ip
  states: {}
- name: iio_attr_updater_0_0
  id: iio_attr_updater
  parameters:
    attr: hardwaregain
    interval: interval_update
    value: str(0)
  states: {}
- name: iio_attr_updater_0_0_0
  id: iio_attr_updater
  parameters:
    attr: hardwaregain
    interval: interval_update
    value: str(-40)
  states: {}
- name: iio_attr_updater_0_1_0
  id: iio_attr_updater
  parameters:
    attr: frequency
    interval: interval_update
    value: str(rx_lo_freq)
  states: {}
- name: iio_attr_updater_0_1_0_1
  id: iio_attr_updater
  parameters:
    attr: gain_control_mode
    interval: interval_update
    value: gain_control_mode_rx0
  states: {}
- name: iio_device_source_0
  id: iio_device_source
  parameters:
    buffer_size: buff_size
    channels: '[''voltage0_i'',''voltage0_q'']'
    decimation: '1'
    device: axi-adrv9002-rx-lpc
    device_phy: adrv9002-phy
    params: '[]'
    uri: jupiter_ip
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: (3,0,1,1)
    label1: '''Rx Before \nCostas Loop'''
    label2: '''Rx After \nCostas Loop'''
    name: Received Constellation
    nconnections: '2'
    size: int(1024)
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
  states: {}
- name: qtgui_eye_sink_x_0_0
  id: qtgui_eye_sink_x
  parameters:
    grid: 'True'
    gui_hint: (3,1,1,1)
    label1: Rx Re (After Costas Loop)
    label2: Rx Im (After Costas Loop)
    samp_per_symbol: '1'
    size: '100'
    srate: samp_rate
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    ymax: '8'
    ymin: '-8'
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    grid: 'True'
    gui_hint: (2,1,1,1)
    label1: Rx
    label2: '''Rx \n+ \nFreq Offset'''
    label3: '''Rx \n+ \nFreq \nOffset \n+ \nFLL'''
    name: '"Received spectrum"'
    nconnections: '3'
    tr_level: '-80'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    update_time: '0.5'
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: (1,1,1,1)
    label1: Re
    label2: Im
    name: '"Received Samples (After Costas Loop)"'
    size: '96'
    srate: samp_rate
    tr_level: '0.8'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    ymax: '10'
    ymin: '-10'
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_fll_band_edge_cc_0, '0']
- [analog_agc_xx_0, '0', qtgui_freq_sink_x_0_0_0, '1']
- [analog_sig_source_x_0_0_0, '0', blocks_multiply_xx_0_0_0, '1']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0_0_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [blocks_multiply_xx_0_0_0, '0', analog_agc_xx_0, '0']
- [blocks_repack_bits_bb_1, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_short_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_short_to_float_0_1, '0', blocks_float_to_complex_0, '1']
- [blocks_skiphead_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [digital_constellation_receiver_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_receiver_cb_0, '1', blocks_null_sink_0_0_0, '0']
- [digital_constellation_receiver_cb_0, '2', blocks_null_sink_0_0, '0']
- [digital_constellation_receiver_cb_0, '3', blocks_null_sink_0, '0']
- [digital_constellation_receiver_cb_0, '4', qtgui_const_sink_x_0_0, '1']
- [digital_constellation_receiver_cb_0, '4', qtgui_eye_sink_x_0_0, '0']
- [digital_constellation_receiver_cb_0, '4', qtgui_time_sink_x_1_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_1, '0']
- [digital_crc_check_0, ok, epy_block_0_0, msg_in]
- [digital_diff_decoder_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_fll_band_edge_cc_0, '0', blocks_skiphead_0, '0']
- [digital_fll_band_edge_cc_0, '0', qtgui_freq_sink_x_0_0_0, '2']
- [digital_symbol_sync_xx_0, '0', digital_constellation_receiver_cb_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0_0, '0']
- [epy_block_0_0, clear_input, blocks_msgpair_to_var_0, inpair]
- [iio_attr_updater_0_0, out, iio_attr_sink_0_0, attr]
- [iio_attr_updater_0_0_0, out, iio_attr_sink_0_0_0, attr]
- [iio_attr_updater_0_1_0, out, iio_attr_sink_0_1_0, attr]
- [iio_attr_updater_0_1_0_1, out, iio_attr_sink_0_1_0_1, attr]
- [iio_device_source_0, '0', blocks_short_to_float_0, '0']
- [iio_device_source_0, '1', blocks_short_to_float_0_1, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, digital_crc_check_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.11.0
